# Keil uVision project object.uvprojx, settings and files
target Amain (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Amain +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\USER-CODE\HARDWARE\SYSTEM;..\USER-CODE\HARDWARE\Inc;..\USER-CODE\USER\Inc;..\USER-CODE\FreeRTOS\include;..\USER-CODE\FreeRTOS\portable\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ../USER-CODE/HARDWARE/: startup_stm32f10x_hd.s
  group CODE/USER
    ../USER-CODE/USER/Src/: main.c
  group CODE/HARDWARE
    ../USER-CODE/HARDWARE/SYSTEM/: delay.c sys.c
    ../USER-CODE/HARDWARE/Src/: key.c usart.c led.c
  group FreeRTOS/CORE
    ../USER-CODE/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/PORTABLE
    ../USER-CODE/FreeRTOS/portable/MemMang/: heap_4.c
    ../USER-CODE/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
